# Keil uVision project CAN-Modules.uvprojx, settings and files
target CAN-Modules (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN-Modules
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\USER;.\FK_Protocols;.\USARTDrivers;.\RTE\Device\STM32F103C8;.\EEPROM;.\CANDrivers;.\RTE
  memory RVCT4: ROM 0x8002800 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./USER/: main.c Timer.c common.c USx_Process.c XYringbuffer.c ADC.c led.c
  group USARTDrivers
    ./USARTDrivers/: usart1.c usart2.c usart3.c
  group FK_Protocols
    ./FK_Protocols/: baseprotocol.c data_transform.c item.c
  group eeprom
    ./EEPROM/: eeprom.c version.c
  group CANDriver
    ./CANDrivers/: can.c can_driver.c can_protocol.c
software components: CMSIS:CORE 4.3.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
